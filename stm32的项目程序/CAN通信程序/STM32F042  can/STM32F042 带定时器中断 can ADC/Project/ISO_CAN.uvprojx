# Keil uVision project ISO_CAN.uvprojx, settings and files
target ISO_CAN (ARM-ADS)
  device: STM32F042G6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00001800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ISO_CAN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F042,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\source\startup\arm;..\Libraries\CMSIS\include;..\Libraries\FWLib\inc;..\User\inc;..\..\19-ISO_CAN_temp\19-ISO_CAN\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: .\Objects\ISO_CAN.sct
  group StartUp
    ../Libraries/CMSIS/source/startup/arm/: startup_stm32f042.s
  group CMSIS
    ../Libraries/CMSIS/source/: system_stm32f0xx.c
  group FWLib
    ../Libraries/FWLib/src/: stm32f0xx_usart.c stm32f0xx_can.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_dma.c stm32f0xx_tim.c stm32f0xx_adc.c
  group User
    ../User/src/: iso_dma.c can.c key.c led.c main.c delay.c timer.c adc.c iso_usart1.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
