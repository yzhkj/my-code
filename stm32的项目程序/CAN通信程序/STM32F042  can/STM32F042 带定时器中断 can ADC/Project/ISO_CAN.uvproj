# Keil uVision project ISO_CAN.uvproj, settings and files
target ISO_CAN (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ISO_CAN
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F042,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\source\startup\arm;..\Libraries\CMSIS\include;..\Libraries\FWLib\inc;..\User\inc
  library: MicroLIB
  group StartUp
    ../Libraries/CMSIS/source/startup/arm/: startup_stm32f042.s
  group CMSIS
    ../Libraries/CMSIS/source/: system_stm32f0xx.c
  group FWLib
    ../Libraries/FWLib/src/: stm32f0xx_usart.c stm32f0xx_can.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_dma.c
  group User
    ../User/src/: iso_can.c iso_main.c iso_usart1.c iso_led.c stm32f0xx_it.c iso_dma.c
